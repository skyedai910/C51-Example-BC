# Keil uVision project 12864.uvproj, settings and files
target Target 1 (MCS-51)
  device: 89C52 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(24000000)
  output: 12864 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 12864A-3.c
