# Keil uVision project 12864tupian.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 12864tupian +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 12864tupian.c
