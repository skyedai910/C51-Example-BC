# Keil uVision project application.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80C51BH Intel
  cpu: IRAM(0-0x7F)  IROM(0-0xFFF) CLOCK(12000000)
  output: application.ofm +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: led.c main.c ad.c control.c keyboard.c menu.c serial.c
